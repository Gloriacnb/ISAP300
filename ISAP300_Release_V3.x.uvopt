<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>LPC3250</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>13000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\UV4Build\LST\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>8</CpuCode>
      <DllOpt>
        <SimDllName>SARM.DLL</SimDllName>
        <SimDllArguments>-cLPC3000</SimDllArguments>
        <SimDlgDllName>DARMP3.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pLPC3250</SimDlgDllArguments>
        <TargetDllName>SARM.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMP3.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pLPC3000</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>15</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile>.\UV4Build\ISAP100_Realese_LPC3250 LPC3250.ini</tIfile>
        <pMon>..\TKScope\ULP2ARM_TKSCP_DRV_ARM_for_AGDI.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ULP2ARM_TKSCP_DRV_ARM_for_AGDI</Key>
          <Name>-VD134322 -EP1179648 -ES1859 -OP1798 -IC0 -LM0 -IF0 -EF0 -VL0 -UT0 -UE0 -OF284498196 -OJ284498212-EO000 -EO010 -EO02134217728 -EO030 -EO04208 -EO050 -EO060 -EO07134217728 -EO080 -EO09208 -EO100 -EO110 -EO12134217728 -EO130 -EO14208 -EO150 -EO160 -EO17134217728 -EO180 -EO19208 -EO201200000 -EO211200000 -EO22100000 -EO231200000 -EO2450 -EO25500 -EO26395472655 -EO277602177 -EO2850500000 -EO2915 -EO300 -EO310 -EO3228 -EO330 -EO340 -EO350 -EO360 -EO370 -EO380 -EO390 -HD000 -HD010 -HD020 -HD030 -HD040 -HD05134322 -OJ000 -OJ010 -OJ020 -OJ030 -OJ040 -OJ050 -OJ060 -OJ070 -FF4"ulp2arm_tkscp_drv_arm_for_agdi lpc3250.ini" -PJ"ISAP300_Release_V3.x_LPC3250.cfg"  -MM0V2T0S0E65535 -MM8V2T0S0E65535</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>ptm</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>cmd</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>expstbus_obj</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>pairuid</ItemText>
        </Ww>
      </WatchWindow1>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>ResultBuff</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <SystemViewers>
        <Entry>
          <Name>OS Support\RTX Tasks and System</Name>
          <WinId>35905</WinId>
        </Entry>
      </SystemViewers>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>source_HAL_BSP_ISAP300_V1.0</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/IRQ.c</PathWithFileName>
      <FilenameWithoutPath>IRQ.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/LPC32x0_arm.s</PathWithFileName>
      <FilenameWithoutPath>LPC32x0_arm.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/RTX_Swi.c</PathWithFileName>
      <FilenameWithoutPath>RTX_Swi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/Retarget.c</PathWithFileName>
      <FilenameWithoutPath>Retarget.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/SWI_Table.s</PathWithFileName>
      <FilenameWithoutPath>SWI_Table.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/bsp_nand.c</PathWithFileName>
      <FilenameWithoutPath>bsp_nand.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/slc_nand.c</PathWithFileName>
      <FilenameWithoutPath>slc_nand.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/TerminalUart.c</PathWithFileName>
      <FilenameWithoutPath>TerminalUart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/bsp_interrupt.c</PathWithFileName>
      <FilenameWithoutPath>bsp_interrupt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/BSP_ISAP300_V1.0/Uart1.c</PathWithFileName>
      <FilenameWithoutPath>Uart1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HAL_lib_LPC32xx_source</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_adc_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_adc_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_clcdc_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_clcdc_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_clkpwr_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_clkpwr_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_dma_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_dma_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_gpio_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_gpio_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_hstimer_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_hstimer_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_hsuart_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_hsuart_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_i2c_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_i2c_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_i2s_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_i2s_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_intc_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_intc_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_kscan_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_kscan_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_mlcnand_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_mlcnand_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_mstimer_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_mstimer_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_mstr_i2c_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_mstr_i2c_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_pwm_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_pwm_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_rtc_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_rtc_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_sdcard_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_sdcard_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_slcnand_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_slcnand_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_spi_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_spi_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_ssp_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_ssp_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_timer_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_timer_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_tsc_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_tsc_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_uart_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_uart_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_vectors.s</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_vectors.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc32xx_wdt_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc32xx_wdt_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/lpc3xxx_spwm_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc3xxx_spwm_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC32xx/source/LPC32_EMAC.c</PathWithFileName>
      <FilenameWithoutPath>LPC32_EMAC.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HAL_lib_LPC_source</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_api.c</PathWithFileName>
      <FilenameWithoutPath>lpc_api.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_arm922t_cp15_driver.c</PathWithFileName>
      <FilenameWithoutPath>lpc_arm922t_cp15_driver.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_bmp.c</PathWithFileName>
      <FilenameWithoutPath>lpc_bmp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_colors.c</PathWithFileName>
      <FilenameWithoutPath>lpc_colors.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_fat16.c</PathWithFileName>
      <FilenameWithoutPath>lpc_fat16.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_fat16_private.c</PathWithFileName>
      <FilenameWithoutPath>lpc_fat16_private.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_fonts.c</PathWithFileName>
      <FilenameWithoutPath>lpc_fonts.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_heap.c</PathWithFileName>
      <FilenameWithoutPath>lpc_heap.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_helvr10.c</PathWithFileName>
      <FilenameWithoutPath>lpc_helvr10.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_lbecc.c</PathWithFileName>
      <FilenameWithoutPath>lpc_lbecc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_lcd_params.c</PathWithFileName>
      <FilenameWithoutPath>lpc_lcd_params.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_line_parser.c</PathWithFileName>
      <FilenameWithoutPath>lpc_line_parser.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_nandflash_params.c</PathWithFileName>
      <FilenameWithoutPath>lpc_nandflash_params.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_rom8x16.c</PathWithFileName>
      <FilenameWithoutPath>lpc_rom8x16.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_rom8x8.c</PathWithFileName>
      <FilenameWithoutPath>lpc_rom8x8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_string.c</PathWithFileName>
      <FilenameWithoutPath>lpc_string.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_swim.c</PathWithFileName>
      <FilenameWithoutPath>lpc_swim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_swim_font.c</PathWithFileName>
      <FilenameWithoutPath>lpc_swim_font.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_swim_image.c</PathWithFileName>
      <FilenameWithoutPath>lpc_swim_image.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_winfreesystem14x16.c</PathWithFileName>
      <FilenameWithoutPath>lpc_winfreesystem14x16.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_x5x7.c</PathWithFileName>
      <FilenameWithoutPath>lpc_x5x7.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/LPC/source/lpc_x6x13.c</PathWithFileName>
      <FilenameWithoutPath>lpc_x6x13.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>60</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/main.cpp</PathWithFileName>
      <FilenameWithoutPath>main.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>61</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/SysInitial.cpp</PathWithFileName>
      <FilenameWithoutPath>SysInitial.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/SysCLI.cpp</PathWithFileName>
      <FilenameWithoutPath>SysCLI.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_platform_filesystem</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>63</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>25</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/filesystem/File_Config.c</PathWithFileName>
      <FilenameWithoutPath>File_Config.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>64</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/filesystem/fs_time.c</PathWithFileName>
      <FilenameWithoutPath>fs_time.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>65</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/filesystem/Getline.c</PathWithFileName>
      <FilenameWithoutPath>Getline.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>66</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/filesystem/NAND_File.c</PathWithFileName>
      <FilenameWithoutPath>NAND_File.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>67</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/filesystem/NandPort.c</PathWithFileName>
      <FilenameWithoutPath>NandPort.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>68</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\platform\filesystem\FS_ARM_L.lib</PathWithFileName>
      <FilenameWithoutPath>FS_ARM_L.lib</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_platform_net</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>69</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/Net_Config.c</PathWithFileName>
      <FilenameWithoutPath>Net_Config.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>70</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/Net_lib.c</PathWithFileName>
      <FilenameWithoutPath>Net_lib.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>71</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/TFTP_uif.c</PathWithFileName>
      <FilenameWithoutPath>TFTP_uif.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>72</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/net_api.c</PathWithFileName>
      <FilenameWithoutPath>net_api.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>73</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/TFTPC_uif.c</PathWithFileName>
      <FilenameWithoutPath>TFTPC_uif.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>74</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/TCPD_ARM_L.lib</PathWithFileName>
      <FilenameWithoutPath>TCPD_ARM_L.lib</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>75</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/Net_Debug.c</PathWithFileName>
      <FilenameWithoutPath>Net_Debug.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>76</FileNumber>
      <FileType>4</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/TCP_ARM_L.lib</PathWithFileName>
      <FilenameWithoutPath>TCP_ARM_L.lib</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>77</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/net/FTP_uif.c</PathWithFileName>
      <FilenameWithoutPath>FTP_uif.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_platform_os_RTX</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>78</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/os/RTX/RTX_Config.c</PathWithFileName>
      <FilenameWithoutPath>RTX_Config.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>79</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/os/RTX/os_init.cpp</PathWithFileName>
      <FilenameWithoutPath>os_init.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_platform_tools</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>80</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/platform/tools/EthMemory.c</PathWithFileName>
      <FilenameWithoutPath>EthMemory.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HAL_lib_SYS_API</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>81</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/SYS_API/sys_except.s</PathWithFileName>
      <FilenameWithoutPath>sys_except.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>82</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/SYS_API/sysapi_misc.c</PathWithFileName>
      <FilenameWithoutPath>sysapi_misc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>83</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/SYS_API/sys_api.c</PathWithFileName>
      <FilenameWithoutPath>sys_api.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
      <FileNumber>84</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HAL/lib/SYS_API/Ethernet.c</PathWithFileName>
      <FilenameWithoutPath>Ethernet.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_MidWare</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>85</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/Mid_CLI.cpp</PathWithFileName>
      <FilenameWithoutPath>Mid_CLI.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>86</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/SoftWDT.cpp</PathWithFileName>
      <FilenameWithoutPath>SoftWDT.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
      <FileNumber>87</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/ISAP100Led.cpp</PathWithFileName>
      <FilenameWithoutPath>ISAP100Led.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_MidWare_CLI_Commands</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>88</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/CLI_Commands/CLI_Debug_cmd_group.cpp</PathWithFileName>
      <FilenameWithoutPath>CLI_Debug_cmd_group.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>89</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/CLI_Commands/CLI_File_cmd_group.cpp</PathWithFileName>
      <FilenameWithoutPath>CLI_File_cmd_group.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>90</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/CLI_Commands/CLI_Config_cmd_group.cpp</PathWithFileName>
      <FilenameWithoutPath>CLI_Config_cmd_group.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
      <FileNumber>91</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/CLI_Commands/CLI_Upgrade_cmd_group.cpp</PathWithFileName>
      <FilenameWithoutPath>CLI_Upgrade_cmd_group.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_MidWare_s1l</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>92</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/s1l/s1l_cmds.c</PathWithFileName>
      <FilenameWithoutPath>s1l_cmds.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
      <FileNumber>93</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/MidWare/s1l/s1l_line_input.c</PathWithFileName>
      <FilenameWithoutPath>s1l_line_input.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_Tools</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>94</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/SysError.cpp</PathWithFileName>
      <FilenameWithoutPath>SysError.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>95</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/UID.cpp</PathWithFileName>
      <FilenameWithoutPath>UID.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>96</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/CPPTools.cpp</PathWithFileName>
      <FilenameWithoutPath>CPPTools.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>97</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/CCheckData.cpp</PathWithFileName>
      <FilenameWithoutPath>CCheckData.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>98</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/TimeSlot2ITUT.cpp</PathWithFileName>
      <FilenameWithoutPath>TimeSlot2ITUT.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>99</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/RTC.cpp</PathWithFileName>
      <FilenameWithoutPath>RTC.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>100</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/CRC7.cpp</PathWithFileName>
      <FilenameWithoutPath>CRC7.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>101</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/SwTrace.cpp</PathWithFileName>
      <FilenameWithoutPath>SwTrace.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>102</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/FileFind.cpp</PathWithFileName>
      <FilenameWithoutPath>FileFind.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>103</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/OutMsg.cpp</PathWithFileName>
      <FilenameWithoutPath>OutMsg.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
      <FileNumber>104</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/Tools/EZLog.cpp</PathWithFileName>
      <FilenameWithoutPath>EZLog.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>105</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/CCardOnlineChecker.cpp</PathWithFileName>
      <FilenameWithoutPath>CCardOnlineChecker.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>106</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/DeviceAttribute.cpp</PathWithFileName>
      <FilenameWithoutPath>DeviceAttribute.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>107</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/DeviceComponent.cpp</PathWithFileName>
      <FilenameWithoutPath>DeviceComponent.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>108</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/SlotModule.cpp</PathWithFileName>
      <FilenameWithoutPath>SlotModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>14</GroupNumber>
      <FileNumber>109</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/CLoopModule.cpp</PathWithFileName>
      <FilenameWithoutPath>CLoopModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_Factory</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>110</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Factory/ComponentFactory.cpp</PathWithFileName>
      <FilenameWithoutPath>ComponentFactory.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>111</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Factory/EmuxCompFac.cpp</PathWithFileName>
      <FilenameWithoutPath>EmuxCompFac.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>15</GroupNumber>
      <FileNumber>112</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Factory/IsapCompFac.cpp</PathWithFileName>
      <FilenameWithoutPath>IsapCompFac.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_card</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>113</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CBaseCard.cpp</PathWithFileName>
      <FilenameWithoutPath>CBaseCard.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>114</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardXC.cpp</PathWithFileName>
      <FilenameWithoutPath>CardXC.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>115</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card24E1.cpp</PathWithFileName>
      <FilenameWithoutPath>Card24E1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>116</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardCPU.cpp</PathWithFileName>
      <FilenameWithoutPath>CardCPU.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>117</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card30VF.cpp</PathWithFileName>
      <FilenameWithoutPath>Card30VF.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>118</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8EOS.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8EOS.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>119</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card48E1.cpp</PathWithFileName>
      <FilenameWithoutPath>Card48E1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>120</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card4STM1.cpp</PathWithFileName>
      <FilenameWithoutPath>Card4STM1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>121</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardVF.cpp</PathWithFileName>
      <FilenameWithoutPath>CardVF.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>122</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card16VF.cpp</PathWithFileName>
      <FilenameWithoutPath>Card16VF.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>123</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8VF.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8VF.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>124</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8STM1.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8STM1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>125</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card16E1.cpp</PathWithFileName>
      <FilenameWithoutPath>Card16E1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>126</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card4EOS.cpp</PathWithFileName>
      <FilenameWithoutPath>Card4EOS.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>127</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card4EOSFX.cpp</PathWithFileName>
      <FilenameWithoutPath>Card4EOSFX.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>128</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8EOSFX.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8EOSFX.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>129</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/XCPair.cpp</PathWithFileName>
      <FilenameWithoutPath>XCPair.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>130</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8EOSN.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8EOSN.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>131</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8EOSFXN.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8EOSFXN.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>132</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card16DATA.cpp</PathWithFileName>
      <FilenameWithoutPath>Card16DATA.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>133</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardFAN.cpp</PathWithFileName>
      <FilenameWithoutPath>CardFAN.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>134</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardV5.cpp</PathWithFileName>
      <FilenameWithoutPath>CardV5.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>135</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardACPOWER.cpp</PathWithFileName>
      <FilenameWithoutPath>CardACPOWER.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>136</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardDCPOWER.cpp</PathWithFileName>
      <FilenameWithoutPath>CardDCPOWER.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>137</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card4EOSN.cpp</PathWithFileName>
      <FilenameWithoutPath>Card4EOSN.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>138</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card4EOSFXN.cpp</PathWithFileName>
      <FilenameWithoutPath>Card4EOSFXN.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>139</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card30MT.cpp</PathWithFileName>
      <FilenameWithoutPath>Card30MT.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>140</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card32FXO.cpp</PathWithFileName>
      <FilenameWithoutPath>Card32FXO.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>141</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card32FXS.cpp</PathWithFileName>
      <FilenameWithoutPath>Card32FXS.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>142</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card16FE1.cpp</PathWithFileName>
      <FilenameWithoutPath>Card16FE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>143</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardDXC.cpp</PathWithFileName>
      <FilenameWithoutPath>CardDXC.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>144</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/Card8DATA.cpp</PathWithFileName>
      <FilenameWithoutPath>Card8DATA.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>16</GroupNumber>
      <FileNumber>145</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/card/CardDATA.cpp</PathWithFileName>
      <FilenameWithoutPath>CardDATA.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_slot</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>146</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/slot/CBaseSlot.cpp</PathWithFileName>
      <FilenameWithoutPath>CBaseSlot.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>147</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/slot/SlotEXT.cpp</PathWithFileName>
      <FilenameWithoutPath>SlotEXT.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>148</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/slot/SlotXC.cpp</PathWithFileName>
      <FilenameWithoutPath>SlotXC.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>149</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/slot/SlotFan.cpp</PathWithFileName>
      <FilenameWithoutPath>SlotFan.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>150</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/slot/SlotPower.cpp</PathWithFileName>
      <FilenameWithoutPath>SlotPower.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>17</GroupNumber>
      <FileNumber>151</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/slot/SlotEXTNoSDH.cpp</PathWithFileName>
      <FilenameWithoutPath>SlotEXTNoSDH.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_chip</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>152</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/BaseChip.cpp</PathWithFileName>
      <FilenameWithoutPath>BaseChip.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>153</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipCP1121A.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipCP1121A.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>154</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/GeneralLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>GeneralLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>155</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipPCMLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipPCMLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>156</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipSDHLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipSDHLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>157</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipUOPTLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipUOPTLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>158</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipE1Logic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipE1Logic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>159</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipRC7883.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipRC7883.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>160</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip30VFLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip30VFLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>161</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipLM75A.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipLM75A.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>162</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8EOSLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8EOSLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>163</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipRC6400.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipRC6400.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>164</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/FPGAChip.cpp</PathWithFileName>
      <FilenameWithoutPath>FPGAChip.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>165</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip24E1CPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip24E1CPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>166</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip30VFCPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip30VFCPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>167</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8EOSCPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8EOSCPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>168</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8STM1CPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8STM1CPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>169</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8STM1Logic1.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8STM1Logic1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>170</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8STM1Logic2.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8STM1Logic2.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>171</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipXCCPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipXCCPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>172</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/DriverSDH.cpp</PathWithFileName>
      <FilenameWithoutPath>DriverSDH.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>173</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/DriverSDH8STM1.cpp</PathWithFileName>
      <FilenameWithoutPath>DriverSDH8STM1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>174</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/DriverSDHXc.cpp</PathWithFileName>
      <FilenameWithoutPath>DriverSDHXc.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>175</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip48E1CPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip48E1CPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>176</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/DriverTrib4STM1.cpp</PathWithFileName>
      <FilenameWithoutPath>DriverTrib4STM1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>177</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip16E1CPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip16E1CPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>178</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip16E1Logic.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip16E1Logic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>179</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ClockZarlink30122.cpp</PathWithFileName>
      <FilenameWithoutPath>ClockZarlink30122.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>180</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8EOSLogicN.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8EOSLogicN.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>181</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip8EOSLogicN2.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip8EOSLogicN2.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>182</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip16DATACPLD.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip16DATACPLD.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>183</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/Chip16DATALogic.cpp</PathWithFileName>
      <FilenameWithoutPath>Chip16DATALogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>184</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipV5Logic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipV5Logic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>185</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipEmuxLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipEmuxLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>186</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/DriverPCM.cpp</PathWithFileName>
      <FilenameWithoutPath>DriverPCM.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>187</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipDXCLogic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipDXCLogic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>18</GroupNumber>
      <FileNumber>188</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/chip/ChipE1Port16Logic.cpp</PathWithFileName>
      <FilenameWithoutPath>ChipE1Port16Logic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>19</GroupNumber>
      <FileNumber>189</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/CommunicationModule.cpp</PathWithFileName>
      <FilenameWithoutPath>CommunicationModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>19</GroupNumber>
      <FileNumber>190</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\communication\InnerDCCManager.cpp</PathWithFileName>
      <FilenameWithoutPath>InnerDCCManager.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>191</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/CSnmpCell.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpCell.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>192</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/CSnmpCommand.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpCommand.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>193</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/CSnmpDataInOut.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpDataInOut.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>194</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/CSnmpStatic.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpStatic.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>195</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/CSnmpVariable.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpVariable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>196</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/CSnmpVariableBinding.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpVariableBinding.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>20</GroupNumber>
      <FileNumber>197</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMP_Process.cpp</PathWithFileName>
      <FilenameWithoutPath>SNMP_Process.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_Depend</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>21</GroupNumber>
      <FileNumber>198</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Depend/CClassPointer.cpp</PathWithFileName>
      <FilenameWithoutPath>CClassPointer.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>21</GroupNumber>
      <FileNumber>199</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Depend/CThreadTask.cpp</PathWithFileName>
      <FilenameWithoutPath>CThreadTask.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>21</GroupNumber>
      <FileNumber>200</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Depend/CUDPData.cpp</PathWithFileName>
      <FilenameWithoutPath>CUDPData.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>201</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibColumn.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibColumn.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>202</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibEntry.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibEntry.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>203</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibGroup.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibGroup.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>204</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibImpl.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibImpl.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>205</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibNodeObject.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibNodeObject.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>206</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>207</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CMibTableColumn.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibTableColumn.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>22</GroupNumber>
      <FileNumber>208</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/CSnmpMib.cpp</PathWithFileName>
      <FilenameWithoutPath>CSnmpMib.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib_Standard</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>23</GroupNumber>
      <FileNumber>209</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Standard/CStdSystem.cpp</PathWithFileName>
      <FilenameWithoutPath>CStdSystem.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SoftSwitch</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>210</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/CFinishedPacket.cpp</PathWithFileName>
      <FilenameWithoutPath>CFinishedPacket.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>211</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/Layer2Tag.cpp</PathWithFileName>
      <FilenameWithoutPath>Layer2Tag.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>212</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/MacPortMap.cpp</PathWithFileName>
      <FilenameWithoutPath>MacPortMap.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>213</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/PriPacket.cpp</PathWithFileName>
      <FilenameWithoutPath>PriPacket.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>214</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/SwitchCore.cpp</PathWithFileName>
      <FilenameWithoutPath>SwitchCore.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>215</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/SwitchPort.cpp</PathWithFileName>
      <FilenameWithoutPath>SwitchPort.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>216</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/SwitchPortCPU.cpp</PathWithFileName>
      <FilenameWithoutPath>SwitchPortCPU.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>217</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/SwitchPortInner.cpp</PathWithFileName>
      <FilenameWithoutPath>SwitchPortInner.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>218</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/SwitchPortStd.cpp</PathWithFileName>
      <FilenameWithoutPath>SwitchPortStd.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>219</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/switchPortSNMP.cpp</PathWithFileName>
      <FilenameWithoutPath>switchPortSNMP.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>220</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/IpPortMap.cpp</PathWithFileName>
      <FilenameWithoutPath>IpPortMap.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>24</GroupNumber>
      <FileNumber>221</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SoftSwitch/PortRecord.cpp</PathWithFileName>
      <FilenameWithoutPath>PortRecord.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_BusinessResource</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>25</GroupNumber>
      <FileNumber>222</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/ConnectableResource.cpp</PathWithFileName>
      <FilenameWithoutPath>ConnectableResource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>25</GroupNumber>
      <FileNumber>223</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/RealPortBase.cpp</PathWithFileName>
      <FilenameWithoutPath>RealPortBase.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>25</GroupNumber>
      <FileNumber>224</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/BaseResource.cpp</PathWithFileName>
      <FilenameWithoutPath>BaseResource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>25</GroupNumber>
      <FileNumber>225</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/PairResource.cpp</PathWithFileName>
      <FilenameWithoutPath>PairResource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>25</GroupNumber>
      <FileNumber>226</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/Resource.cpp</PathWithFileName>
      <FilenameWithoutPath>Resource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_CrossConnectionModule</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>26</GroupNumber>
      <FileNumber>227</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/CrossConnectionModule/CCrossConnection.cpp</PathWithFileName>
      <FilenameWithoutPath>CCrossConnection.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>26</GroupNumber>
      <FileNumber>228</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/CrossConnectionModule/CrossConnectionManager.cpp</PathWithFileName>
      <FilenameWithoutPath>CrossConnectionManager.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib_Private_ModuleGroup</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>229</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibFunctionModuleGroup.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibFunctionModuleGroup.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>230</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibModule.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>231</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibXCAddTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibXCAddTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>232</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibXCProperty.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibXCProperty.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>233</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/TableClockSourceOption.cpp</PathWithFileName>
      <FilenameWithoutPath>TableClockSourceOption.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>234</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/TableDeviceClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>TableDeviceClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>235</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/TableUseableClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>TableUseableClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>236</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibLoopAddTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibLoopAddTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>237</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibLoopPropertyTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibLoopPropertyTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>238</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/CMibLoopablePortTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibLoopablePortTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>239</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/PcmClockOptionTable.cpp</PathWithFileName>
      <FilenameWithoutPath>PcmClockOptionTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>240</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/PcmClockSourceTable.cpp</PathWithFileName>
      <FilenameWithoutPath>PcmClockSourceTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>241</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/PcmUseableClockSourceTable.cpp</PathWithFileName>
      <FilenameWithoutPath>PcmUseableClockSourceTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>242</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/TableDeviceFiles.cpp</PathWithFileName>
      <FilenameWithoutPath>TableDeviceFiles.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>27</GroupNumber>
      <FileNumber>243</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/TableDeviceBitFiles.cpp</PathWithFileName>
      <FilenameWithoutPath>TableDeviceBitFiles.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_compmisc</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>28</GroupNumber>
      <FileNumber>244</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/EZbus.cpp</PathWithFileName>
      <FilenameWithoutPath>EZbus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>28</GroupNumber>
      <FileNumber>245</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/RegisterAccess.cpp</PathWithFileName>
      <FilenameWithoutPath>RegisterAccess.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>28</GroupNumber>
      <FileNumber>246</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/ObjectReference.cpp</PathWithFileName>
      <FilenameWithoutPath>ObjectReference.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>28</GroupNumber>
      <FileNumber>247</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/ResetModule.cpp</PathWithFileName>
      <FilenameWithoutPath>ResetModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>28</GroupNumber>
      <FileNumber>248</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/FANPOWModule.cpp</PathWithFileName>
      <FilenameWithoutPath>FANPOWModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib_Private_InterfaceGroup</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>249</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibSTM.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibSTM.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>250</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibSTMConfig.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibSTMConfig.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>251</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibSTMOverheadTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibSTMOverheadTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>252</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibCrossResource.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibCrossResource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>253</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibInterface.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibInterface.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>254</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibSDHBusTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibSDHBusTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>255</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibSDHChannelTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibSDHChannelTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>256</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibHPTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibHPTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>257</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibLPTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibLPTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>258</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibDataPortTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibDataPortTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>259</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibTS.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibTS.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>260</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibTSChannelTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibTSChannelTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>261</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibVFPortTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibVFPortTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>262</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibE1.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>263</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibE1PortTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibE1PortTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>264</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibChvcTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibChvcTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>265</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibVcgConfigTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibVcgConfigTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>266</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibVcgGroup.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibVcgGroup.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>267</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibVcgMemberTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibVcgMemberTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>268</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibHPOverheadTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibHPOverheadTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>269</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibSltchTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibSltchTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>270</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibFE1PortTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibFE1PortTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>271</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibNMPortGroup.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibNMPortGroup.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>29</GroupNumber>
      <FileNumber>272</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/CMibNMPortTable.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibNMPortTable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib_Private_ElementGroup</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>273</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/CMibNEStruct.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibNEStruct.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>274</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/GroupCardList.cpp</PathWithFileName>
      <FilenameWithoutPath>GroupCardList.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>275</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/GroupDeviceList.cpp</PathWithFileName>
      <FilenameWithoutPath>GroupDeviceList.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>276</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/GroupTopology.cpp</PathWithFileName>
      <FilenameWithoutPath>GroupTopology.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>277</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/NEStructGroup.cpp</PathWithFileName>
      <FilenameWithoutPath>NEStructGroup.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>278</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/TableDevice.cpp</PathWithFileName>
      <FilenameWithoutPath>TableDevice.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>279</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/TableSlot.cpp</PathWithFileName>
      <FilenameWithoutPath>TableSlot.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>280</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/TableTopoOption.cpp</PathWithFileName>
      <FilenameWithoutPath>TableTopoOption.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>30</GroupNumber>
      <FileNumber>281</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/TableTopoStatus.cpp</PathWithFileName>
      <FilenameWithoutPath>TableTopoStatus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib_Private_AttributeGroup</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>31</GroupNumber>
      <FileNumber>282</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AttributeGroup/CMibAttribute.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibAttribute.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>31</GroupNumber>
      <FileNumber>283</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AttributeGroup/CMibBasicAttribute.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibBasicAttribute.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>31</GroupNumber>
      <FileNumber>284</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AttributeGroup/CMibCommunicationAttribute.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibCommunicationAttribute.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>31</GroupNumber>
      <FileNumber>285</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AttributeGroup/CMibDateAttribute.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibDateAttribute.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_UpDataMain</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>32</GroupNumber>
      <FileNumber>286</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/UpDataMain/CMSSave.cpp</PathWithFileName>
      <FilenameWithoutPath>CMSSave.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>32</GroupNumber>
      <FileNumber>287</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/UpDataMain/Lpc3250upload.cpp</PathWithFileName>
      <FilenameWithoutPath>Lpc3250upload.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>32</GroupNumber>
      <FileNumber>288</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/UpDataMain/Mid_FlashData.c</PathWithFileName>
      <FilenameWithoutPath>Mid_FlashData.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>32</GroupNumber>
      <FileNumber>289</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/UpDataMain/Mid_NandFlash.c</PathWithFileName>
      <FilenameWithoutPath>Mid_NandFlash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>32</GroupNumber>
      <FileNumber>290</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/UpDataMain/cfg_save_nand.c</PathWithFileName>
      <FilenameWithoutPath>cfg_save_nand.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_BusinessClockSource</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>291</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/ClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>ClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>292</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/ClockSourceManager.cpp</PathWithFileName>
      <FilenameWithoutPath>ClockSourceManager.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>293</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/XcExtClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>XcExtClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>294</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/XcOPTClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>XcOPTClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>295</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/XcLocalClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>XcLocalClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>296</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/XcPCMClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>XcPCMClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>33</GroupNumber>
      <FileNumber>297</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessClockSource/F16E1PCMClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>F16E1PCMClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_TopologyModule</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>34</GroupNumber>
      <FileNumber>298</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/TopologyModule/TopoManager.cpp</PathWithFileName>
      <FilenameWithoutPath>TopoManager.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_compmisc_VFCommand</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>299</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdRegRead.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdRegRead.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>300</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTSEnable.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTSEnable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>301</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTSLoop.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTSLoop.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>302</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTSMode.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTSMode.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>303</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTSPolarTurn.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTSPolarTurn.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>304</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTSRcvGain.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTSRcvGain.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>305</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTSSndGain.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTSSndGain.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>306</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdTsType.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdTsType.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>307</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCommand.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCommand.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>308</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdRegWrite.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdRegWrite.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>309</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdCoeRead.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdCoeRead.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>310</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdCoeWrite.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdCoeWrite.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>311</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdCardInit.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdCardInit.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>312</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdMcuVer.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdMcuVer.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>313</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdSignalConfig.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdSignalConfig.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>35</GroupNumber>
      <FileNumber>314</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/VFCommand/VFCmdSignalStatus.cpp</PathWithFileName>
      <FilenameWithoutPath>VFCmdSignalStatus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_AlarmFrame</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>315</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/AlarmInstance.cpp</PathWithFileName>
      <FilenameWithoutPath>AlarmInstance.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>316</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/AlarmRecord.cpp</PathWithFileName>
      <FilenameWithoutPath>AlarmRecord.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>317</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/BAlarmDisplay.cpp</PathWithFileName>
      <FilenameWithoutPath>BAlarmDisplay.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>318</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/BAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>BAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>319</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/BAlarmSource.cpp</PathWithFileName>
      <FilenameWithoutPath>BAlarmSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>320</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/AlarmPropertyTemplate.cpp</PathWithFileName>
      <FilenameWithoutPath>AlarmPropertyTemplate.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>321</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/DisplayEverySignal.cpp</PathWithFileName>
      <FilenameWithoutPath>DisplayEverySignal.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>36</GroupNumber>
      <FileNumber>322</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/AlarmFrame/DisplayMultiSignalOR.cpp</PathWithFileName>
      <FilenameWithoutPath>DisplayMultiSignalOR.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_XCAlarm</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>323</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/XCAlarm/SrcSTMPort.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcSTMPort.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>324</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/XCAlarm/XCAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>XCAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>325</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/XCAlarm/XCLEDLOS.cpp</PathWithFileName>
      <FilenameWithoutPath>XCLEDLOS.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>326</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/XCAlarm/XCLEDALM.cpp</PathWithFileName>
      <FilenameWithoutPath>XCLEDALM.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>327</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/XCAlarm/SrcAlarmVC4.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcAlarmVC4.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>37</GroupNumber>
      <FileNumber>328</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/XCAlarm/SrcGroupSTMPort.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcGroupSTMPort.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_SNMPMib_Private_AlarmGroup</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>329</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/CMibAlarm.cpp</PathWithFileName>
      <FilenameWithoutPath>CMibAlarm.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>330</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/GroupAlarmProperty.cpp</PathWithFileName>
      <FilenameWithoutPath>GroupAlarmProperty.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>331</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/GroupAlarmRecord.cpp</PathWithFileName>
      <FilenameWithoutPath>GroupAlarmRecord.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>332</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/TableAlarmPropertyConfig.cpp</PathWithFileName>
      <FilenameWithoutPath>TableAlarmPropertyConfig.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>333</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/TableAlarmPropertyTemplateConfig.cpp</PathWithFileName>
      <FilenameWithoutPath>TableAlarmPropertyTemplateConfig.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>334</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/TableAlarmPropertyTemplateOperation.cpp</PathWithFileName>
      <FilenameWithoutPath>TableAlarmPropertyTemplateOperation.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>38</GroupNumber>
      <FileNumber>335</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/TableCurrentAlarm.cpp</PathWithFileName>
      <FilenameWithoutPath>TableCurrentAlarm.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_E1CardAlarm</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>336</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/E1CardAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>E1CardAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>337</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/SrcAlarmE1.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcAlarmE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>338</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/E1LEDs.cpp</PathWithFileName>
      <FilenameWithoutPath>E1LEDs.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>339</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/E1Card48AlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>E1Card48AlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>340</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/E1Card16AlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>E1Card16AlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>341</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/E1LEDWork.cpp</PathWithFileName>
      <FilenameWithoutPath>E1LEDWork.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>342</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/SrcAlarm16E1.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcAlarm16E1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>39</GroupNumber>
      <FileNumber>343</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/E1CardAlarm/E1LEDAis.cpp</PathWithFileName>
      <FilenameWithoutPath>E1LEDAis.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_TribSTMAlarm</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>40</GroupNumber>
      <FileNumber>344</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/TribSTMAlarm/SrcTribSTMPort.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcTribSTMPort.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>40</GroupNumber>
      <FileNumber>345</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/TribSTMAlarm/Trib4STM1AlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>Trib4STM1AlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>40</GroupNumber>
      <FileNumber>346</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/TribSTMAlarm/Trib8STM1AlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>Trib8STM1AlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>40</GroupNumber>
      <FileNumber>347</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/TribSTMAlarm/TribSTMLEDALM.cpp</PathWithFileName>
      <FilenameWithoutPath>TribSTMLEDALM.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>40</GroupNumber>
      <FileNumber>348</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/TribSTMAlarm/TribSTMLEDLOS.cpp</PathWithFileName>
      <FilenameWithoutPath>TribSTMLEDLOS.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_EOSCardAlarm</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>41</GroupNumber>
      <FileNumber>349</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EOSCardAlarm/EOS4CardAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>EOS4CardAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>41</GroupNumber>
      <FileNumber>350</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EOSCardAlarm/EOS8CardAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>EOS8CardAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>41</GroupNumber>
      <FileNumber>351</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EOSCardAlarm/SrcAlarmVCG.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcAlarmVCG.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>41</GroupNumber>
      <FileNumber>352</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EOSCardAlarm/EOS4NCardAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>EOS4NCardAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>41</GroupNumber>
      <FileNumber>353</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EOSCardAlarm/EOS8NCardAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>EOS8NCardAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_base</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>42</GroupNumber>
      <FileNumber>354</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/base/ConfigCell.cpp</PathWithFileName>
      <FilenameWithoutPath>ConfigCell.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_BusinessResource_OtherCardResource</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>355</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\OtherCardResource\CHVC.cpp</PathWithFileName>
      <FilenameWithoutPath>CHVC.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>356</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\OtherCardResource\PortData.cpp</PathWithFileName>
      <FilenameWithoutPath>PortData.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>357</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\OtherCardResource\PortE1.cpp</PathWithFileName>
      <FilenameWithoutPath>PortE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>358</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\OtherCardResource\PortVF.cpp</PathWithFileName>
      <FilenameWithoutPath>PortVF.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>359</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\OtherCardResource\Slot155Channel.cpp</PathWithFileName>
      <FilenameWithoutPath>Slot155Channel.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>360</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\OtherCardResource\VCG.cpp</PathWithFileName>
      <FilenameWithoutPath>VCG.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>43</GroupNumber>
      <FileNumber>361</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/OtherCardResource/PortFE1.cpp</PathWithFileName>
      <FilenameWithoutPath>PortFE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_BusinessResource_XCResource</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>362</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\CExtE1.cpp</PathWithFileName>
      <FilenameWithoutPath>CExtE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>363</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\CInnerE1.cpp</PathWithFileName>
      <FilenameWithoutPath>CInnerE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>364</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\CSTBus.cpp</PathWithFileName>
      <FilenameWithoutPath>CSTBus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>365</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\CTSChannel.cpp</PathWithFileName>
      <FilenameWithoutPath>CTSChannel.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>366</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\PortSTM4.cpp</PathWithFileName>
      <FilenameWithoutPath>PortSTM4.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>367</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\RscSDHBus.cpp</PathWithFileName>
      <FilenameWithoutPath>RscSDHBus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>368</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\RscSDHChannel.cpp</PathWithFileName>
      <FilenameWithoutPath>RscSDHChannel.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>369</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\RscVC4.cpp</PathWithFileName>
      <FilenameWithoutPath>RscVC4.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>44</GroupNumber>
      <FileNumber>370</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\BusinessResource\XCResource\RscVC12.cpp</PathWithFileName>
      <FilenameWithoutPath>RscVC12.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_BusinessResource_XCPairResource</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>371</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairPortSTM.cpp</PathWithFileName>
      <FilenameWithoutPath>PairPortSTM.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>372</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairRscConnectable.cpp</PathWithFileName>
      <FilenameWithoutPath>PairRscConnectable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>373</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairRscSDHBus.cpp</PathWithFileName>
      <FilenameWithoutPath>PairRscSDHBus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>374</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairRscVC4.cpp</PathWithFileName>
      <FilenameWithoutPath>PairRscVC4.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>375</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairRscSDHChannel.cpp</PathWithFileName>
      <FilenameWithoutPath>PairRscSDHChannel.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>376</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairClockSource.cpp</PathWithFileName>
      <FilenameWithoutPath>PairClockSource.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>377</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairSTBus.cpp</PathWithFileName>
      <FilenameWithoutPath>PairSTBus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>378</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairTSChannel.cpp</PathWithFileName>
      <FilenameWithoutPath>PairTSChannel.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>379</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairRscVC12.cpp</PathWithFileName>
      <FilenameWithoutPath>PairRscVC12.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>45</GroupNumber>
      <FileNumber>380</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/BusinessResource/XCPairResource/PairPortFE1.cpp</PathWithFileName>
      <FilenameWithoutPath>PairPortFE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_Protect</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>381</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/OMUStandby.cpp</PathWithFileName>
      <FilenameWithoutPath>OMUStandby.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>382</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/OMUStatus.cpp</PathWithFileName>
      <FilenameWithoutPath>OMUStatus.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>383</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/OMUWorking.cpp</PathWithFileName>
      <FilenameWithoutPath>OMUWorking.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>384</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/ProtectAssistCell.cpp</PathWithFileName>
      <FilenameWithoutPath>ProtectAssistCell.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>385</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/OMUIdle.cpp</PathWithFileName>
      <FilenameWithoutPath>OMUIdle.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>386</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/SyncFileAPI.cpp</PathWithFileName>
      <FilenameWithoutPath>SyncFileAPI.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>46</GroupNumber>
      <FileNumber>387</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/Protect/SyncFileBakAPI.cpp</PathWithFileName>
      <FilenameWithoutPath>SyncFileBakAPI.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_ComponentElement_compmisc_FANPOWCommand</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>47</GroupNumber>
      <FileNumber>388</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/FANPOWCommand/FANPOWOnLine.cpp</PathWithFileName>
      <FilenameWithoutPath>FANPOWOnLine.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>47</GroupNumber>
      <FileNumber>389</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/FANPOWCommand/CmdRing.cpp</PathWithFileName>
      <FilenameWithoutPath>CmdRing.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>47</GroupNumber>
      <FileNumber>390</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/ComponentElement/compmisc/FANPOWCommand/CmdFanCtrl.cpp</PathWithFileName>
      <FilenameWithoutPath>CmdFanCtrl.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>47</GroupNumber>
      <FileNumber>391</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\ComponentElement\compmisc\FANPOWCommand\CmdFanVer.cpp</PathWithFileName>
      <FilenameWithoutPath>CmdFanVer.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_EmuxXCAlarm</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>48</GroupNumber>
      <FileNumber>392</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EmuxXCAlarm/DXCAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>DXCAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>48</GroupNumber>
      <FileNumber>393</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EmuxXCAlarm/SrcAlarmUpE1.cpp</PathWithFileName>
      <FilenameWithoutPath>SrcAlarmUpE1.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>48</GroupNumber>
      <FileNumber>394</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EmuxXCAlarm/UpE1LEDALM.cpp</PathWithFileName>
      <FilenameWithoutPath>UpE1LEDALM.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>48</GroupNumber>
      <FileNumber>395</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/EmuxXCAlarm/UpE1LEDWork.cpp</PathWithFileName>
      <FilenameWithoutPath>UpE1LEDWork.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_AlarmModule_FECardAlarm</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>49</GroupNumber>
      <FileNumber>396</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/AlarmModule/FECardAlarm/FE1CardAlarmModule.cpp</PathWithFileName>
      <FilenameWithoutPath>FE1CardAlarmModule.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_SNMP_Trap</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>397</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/AllInOneVariable.cpp</PathWithFileName>
      <FilenameWithoutPath>AllInOneVariable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>398</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/Counter32.cpp</PathWithFileName>
      <FilenameWithoutPath>Counter32.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>399</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/Counter64.cpp</PathWithFileName>
      <FilenameWithoutPath>Counter64.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>400</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/Gauge32.cpp</PathWithFileName>
      <FilenameWithoutPath>Gauge32.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>401</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/Integer32.cpp</PathWithFileName>
      <FilenameWithoutPath>Integer32.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>402</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/IpAddress.cpp</PathWithFileName>
      <FilenameWithoutPath>IpAddress.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>403</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/Null.cpp</PathWithFileName>
      <FilenameWithoutPath>Null.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>404</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/OID.cpp</PathWithFileName>
      <FilenameWithoutPath>OID.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>405</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/OctetString.cpp</PathWithFileName>
      <FilenameWithoutPath>OctetString.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>406</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/SNMPPdu.cpp</PathWithFileName>
      <FilenameWithoutPath>SNMPPdu.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>407</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/TimeTicks.cpp</PathWithFileName>
      <FilenameWithoutPath>TimeTicks.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>408</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/TrapList.cpp</PathWithFileName>
      <FilenameWithoutPath>TrapList.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>409</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/Variable.cpp</PathWithFileName>
      <FilenameWithoutPath>Variable.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>410</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/VariableBinding.cpp</PathWithFileName>
      <FilenameWithoutPath>VariableBinding.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>50</GroupNumber>
      <FileNumber>411</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/SNMP/Trap/VariableBindings.cpp</PathWithFileName>
      <FilenameWithoutPath>VariableBindings.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>source_HIS_app_communication_NMPort</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>51</GroupNumber>
      <FileNumber>412</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/NMPort/ChannelSabit.cpp</PathWithFileName>
      <FilenameWithoutPath>ChannelSabit.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>51</GroupNumber>
      <FileNumber>413</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/NMPort/ChannelTsDcn.cpp</PathWithFileName>
      <FilenameWithoutPath>ChannelTsDcn.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>51</GroupNumber>
      <FileNumber>414</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/NMPort/NMChannel.cpp</PathWithFileName>
      <FilenameWithoutPath>NMChannel.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>51</GroupNumber>
      <FileNumber>415</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>./source/HIS/app/communication/NMPort/NMPort.cpp</PathWithFileName>
      <FilenameWithoutPath>NMPort.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>51</GroupNumber>
      <FileNumber>416</FileNumber>
      <FileType>8</FileType>
      <tvExp>0</tvExp>
      <Focus>1</Focus>
      <ColumnNumber>32443152</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>5</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\HIS\app\communication\NMPort\ChannelDcc.cpp</PathWithFileName>
      <FilenameWithoutPath>ChannelDcc.cpp</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

</ProjectOpt>
