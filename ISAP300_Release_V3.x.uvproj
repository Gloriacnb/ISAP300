# Keil uVision project ISAP300_Release_V3.x.uvproj, settings and files
target LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: ISAP300_Release_V0
  AfterMake: fromelf --bin --output ./bin/ISAP300_Release_V0.bin ./UV4Build/OBJ/ISAP300_Release_V0.axf
  AfterMake: addcrc.bat
  c flags: Optim=1 oTime=1 wLevel=1
  c define: STDIO EZ_DEBUG
  c misc: --exceptions
  c include: .\source\HAL\include;.\source\HAL\lib\LPC32xx\include;.\source\HAL\lib\LPC\include;.\source\HIS\include;.\source\HIS\platform\os\include;.\source\HIS\platform\filesystem;.\source\HIS\platform\net;.\source\HIS\platform\tools;.\source\HIS\platform\os\RTX;.\source\HAL\lib\SYS_API\include;.\source\HIS\include\MidWare;.\source\HIS\include\ComponentElement;.\source\HAL\lib\CP1121A\inc;.\source\HIS\app\communication\SoftSwitch;.\source\HIS\app\communication\SNMP;.\source\HIS\app\communication\SNMP\SNMPMib\include;.\source\HIS\app\communication\SNMP\SNMPMib;.\source\HIS\app\communication\SNMP\Depend;.\source\HIS\app\communication;.\source\HIS\app\communication\SNMP\SNMPMib\Private\ModuleGroup;.\source\HIS\app\BusinessResource;.\source\HIS\app\communication\SNMP\SNMPMib\Private\ElementGroup;.\source\HIS\app\UpDataMain;.\source\HIS\app\BusinessClockSource;.\source\HIS\app\communication\TopologyModule;.\source\HIS\app\ComponentElement\compmisc\VFCommand;.\source\HIS\app\AlarmModule\AlarmFrame;.\source\HIS\app\AlarmModule\XCAlarm;.\source\HIS\app\communication\SNMP\SNMPMib\Private\AlarmGroup;.\source\HIS\app\AlarmModule\E1CardAlarm;.\source\HIS\app\AlarmModule\TribSTMAlarm;.\source\HIS\app\AlarmModule\EOSCardAlarm;.\source\HIS\app\BusinessResource\OtherCardResource;.\source\HIS\app\BusinessResource\XCPairResource;.\source\HIS\app\BusinessResource\XCResource;.\source\HIS\app\ComponentElement\Protect;.\source\HIS\app\ComponentElement\compmisc\FANPOWCommand;.\source\HIS\app\AlarmModule\EmuxXCAlarm;.\source\HIS\app\AlarmModule\FECardAlarm;.\source\HIS\app\communication\SNMP\Trap;.\source\HIS\app\communication\NMPort
  asm define: RAM_INTVEC REMAP
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\UV4Build\ISAP300_Realese.sct
  group source_HAL_BSP_ISAP300_V1.0
    ./source/HAL/BSP_ISAP300_V1.0/: IRQ.c LPC32x0_arm.s RTX_Swi.c Retarget.c SWI_Table.s bsp_nand.c slc_nand.c TerminalUart.c bsp_interrupt.c Uart1.c
  group source_HAL_lib_LPC32xx_source
    ./source/HAL/lib/LPC32xx/source/: lpc32xx_adc_driver.c lpc32xx_clcdc_driver.c lpc32xx_clkpwr_driver.c lpc32xx_dma_driver.c lpc32xx_gpio_driver.c lpc32xx_hstimer_driver.c lpc32xx_hsuart_driver.c lpc32xx_i2c_driver.c lpc32xx_i2s_driver.c lpc32xx_intc_driver.c lpc32xx_kscan_driver.c lpc32xx_mlcnand_driver.c lpc32xx_mstimer_driver.c lpc32xx_mstr_i2c_driver.c lpc32xx_pwm_driver.c lpc32xx_rtc_driver.c lpc32xx_sdcard_driver.c lpc32xx_slcnand_driver.c lpc32xx_spi_driver.c lpc32xx_ssp_driver.c lpc32xx_timer_driver.c lpc32xx_tsc_driver.c lpc32xx_uart_driver.c lpc32xx_vectors.s lpc32xx_wdt_driver.c lpc3xxx_spwm_driver.c LPC32_EMAC.c
  group source_HAL_lib_LPC_source
    ./source/HAL/lib/LPC/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x16.c lpc_rom8x8.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
  group source_HIS_app
    ./source/HIS/app/: main.cpp SysInitial.cpp SysCLI.cpp
  group source_HIS_platform_filesystem
    ./source/HIS/platform/filesystem/: File_Config.c fs_time.c Getline.c NAND_File.c NandPort.c FS_ARM_L.lib
  group source_HIS_platform_net
    ./source/HIS/platform/net/: Net_Config.c Net_lib.c TFTP_uif.c net_api.c TFTPC_uif.c TCPD_ARM_L.lib Net_Debug.c TCP_ARM_L.lib FTP_uif.c
  group source_HIS_platform_os_RTX
    ./source/HIS/platform/os/RTX/: RTX_Config.c os_init.cpp
  group source_HIS_platform_tools
    ./source/HIS/platform/tools/: EthMemory.c
  group source_HAL_lib_SYS_API
    ./source/HAL/lib/SYS_API/: sys_except.s sysapi_misc.c sys_api.c Ethernet.c
  group source_HIS_app_MidWare
    ./source/HIS/app/MidWare/: Mid_CLI.cpp SoftWDT.cpp ISAP100Led.cpp
  group source_HIS_app_MidWare_CLI_Commands
    ./source/HIS/app/MidWare/CLI_Commands/: CLI_Debug_cmd_group.cpp CLI_File_cmd_group.cpp CLI_Config_cmd_group.cpp CLI_Upgrade_cmd_group.cpp
  group source_HIS_app_MidWare_s1l
    ./source/HIS/app/MidWare/s1l/: s1l_cmds.c s1l_line_input.c
  group source_HIS_Tools
    ./source/HIS/Tools/: SysError.cpp UID.cpp CPPTools.cpp CCheckData.cpp TimeSlot2ITUT.cpp RTC.cpp CRC7.cpp SwTrace.cpp FileFind.cpp OutMsg.cpp EZLog.cpp
  group source_HIS_app_ComponentElement
    ./source/HIS/app/ComponentElement/: CCardOnlineChecker.cpp DeviceAttribute.cpp DeviceComponent.cpp SlotModule.cpp CLoopModule.cpp
  group source_HIS_app_ComponentElement_Factory
    ./source/HIS/app/ComponentElement/Factory/: ComponentFactory.cpp EmuxCompFac.cpp IsapCompFac.cpp
  group source_HIS_app_ComponentElement_card
    ./source/HIS/app/ComponentElement/card/: CBaseCard.cpp CardXC.cpp Card24E1.cpp CardCPU.cpp Card30VF.cpp Card8EOS.cpp Card48E1.cpp Card4STM1.cpp CardVF.cpp Card16VF.cpp Card8VF.cpp Card8STM1.cpp Card16E1.cpp Card4EOS.cpp Card4EOSFX.cpp Card8EOSFX.cpp XCPair.cpp Card8EOSN.cpp Card8EOSFXN.cpp Card16DATA.cpp CardFAN.cpp CardV5.cpp CardACPOWER.cpp CardDCPOWER.cpp Card4EOSN.cpp Card4EOSFXN.cpp Card30MT.cpp Card32FXO.cpp Card32FXS.cpp Card16FE1.cpp CardDXC.cpp Card8DATA.cpp CardDATA.cpp
  group source_HIS_app_ComponentElement_slot
    ./source/HIS/app/ComponentElement/slot/: CBaseSlot.cpp SlotEXT.cpp SlotXC.cpp SlotFan.cpp SlotPower.cpp SlotEXTNoSDH.cpp
  group source_HIS_app_ComponentElement_chip
    ./source/HIS/app/ComponentElement/chip/: BaseChip.cpp ChipCP1121A.cpp GeneralLogic.cpp ChipPCMLogic.cpp ChipSDHLogic.cpp ChipUOPTLogic.cpp ChipE1Logic.cpp ChipRC7883.cpp Chip30VFLogic.cpp ChipLM75A.cpp Chip8EOSLogic.cpp ChipRC6400.cpp FPGAChip.cpp Chip24E1CPLD.cpp Chip30VFCPLD.cpp Chip8EOSCPLD.cpp Chip8STM1CPLD.cpp Chip8STM1Logic1.cpp Chip8STM1Logic2.cpp ChipXCCPLD.cpp DriverSDH.cpp DriverSDH8STM1.cpp DriverSDHXc.cpp Chip48E1CPLD.cpp DriverTrib4STM1.cpp Chip16E1CPLD.cpp Chip16E1Logic.cpp ClockZarlink30122.cpp Chip8EOSLogicN.cpp Chip8EOSLogicN2.cpp Chip16DATACPLD.cpp Chip16DATALogic.cpp ChipV5Logic.cpp ChipEmuxLogic.cpp DriverPCM.cpp ChipDXCLogic.cpp ChipE1Port16Logic.cpp
  group source_HIS_app_communication
    ./source/HIS/app/communication/: CommunicationModule.cpp InnerDCCManager.cpp
  group source_HIS_app_communication_SNMP
    ./source/HIS/app/communication/SNMP/: CSnmpCell.cpp CSnmpCommand.cpp CSnmpDataInOut.cpp CSnmpStatic.cpp CSnmpVariable.cpp CSnmpVariableBinding.cpp SNMP_Process.cpp
  group source_HIS_app_communication_SNMP_Depend
    ./source/HIS/app/communication/SNMP/Depend/: CClassPointer.cpp CThreadTask.cpp CUDPData.cpp
  group source_HIS_app_communication_SNMP_SNMPMib
    ./source/HIS/app/communication/SNMP/SNMPMib/: CMibColumn.cpp CMibEntry.cpp CMibGroup.cpp CMibImpl.cpp CMibNodeObject.cpp CMibTable.cpp CMibTableColumn.cpp CSnmpMib.cpp
  group source_HIS_app_communication_SNMP_SNMPMib_Standard
    ./source/HIS/app/communication/SNMP/SNMPMib/Standard/: CStdSystem.cpp
  group source_HIS_app_communication_SoftSwitch
    ./source/HIS/app/communication/SoftSwitch/: CFinishedPacket.cpp Layer2Tag.cpp MacPortMap.cpp PriPacket.cpp SwitchCore.cpp SwitchPort.cpp SwitchPortCPU.cpp SwitchPortInner.cpp SwitchPortStd.cpp switchPortSNMP.cpp IpPortMap.cpp PortRecord.cpp
  group source_HIS_app_BusinessResource
    ./source/HIS/app/BusinessResource/: ConnectableResource.cpp RealPortBase.cpp BaseResource.cpp PairResource.cpp Resource.cpp
  group source_HIS_app_CrossConnectionModule
    ./source/HIS/app/CrossConnectionModule/: CCrossConnection.cpp CrossConnectionManager.cpp
  group source_HIS_app_communication_SNMP_SNMPMib_Private_ModuleGroup
    ./source/HIS/app/communication/SNMP/SNMPMib/Private/ModuleGroup/: CMibFunctionModuleGroup.cpp CMibModule.cpp CMibXCAddTable.cpp CMibXCProperty.cpp TableClockSourceOption.cpp TableDeviceClockSource.cpp TableUseableClockSource.cpp CMibLoopAddTable.cpp CMibLoopPropertyTable.cpp CMibLoopablePortTable.cpp PcmClockOptionTable.cpp PcmClockSourceTable.cpp PcmUseableClockSourceTable.cpp TableDeviceFiles.cpp TableDeviceBitFiles.cpp
  group source_HIS_app_ComponentElement_compmisc
    ./source/HIS/app/ComponentElement/compmisc/: EZbus.cpp RegisterAccess.cpp ObjectReference.cpp ResetModule.cpp FANPOWModule.cpp
  group source_HIS_app_communication_SNMP_SNMPMib_Private_InterfaceGroup
    ./source/HIS/app/communication/SNMP/SNMPMib/Private/InterfaceGroup/: CMibSTM.cpp CMibSTMConfig.cpp CMibSTMOverheadTable.cpp CMibCrossResource.cpp CMibInterface.cpp CMibSDHBusTable.cpp CMibSDHChannelTable.cpp CMibHPTable.cpp CMibLPTable.cpp CMibDataPortTable.cpp CMibTS.cpp CMibTSChannelTable.cpp CMibVFPortTable.cpp CMibE1.cpp CMibE1PortTable.cpp CMibChvcTable.cpp CMibVcgConfigTable.cpp CMibVcgGroup.cpp CMibVcgMemberTable.cpp CMibHPOverheadTable.cpp CMibSltchTable.cpp CMibFE1PortTable.cpp CMibNMPortGroup.cpp CMibNMPortTable.cpp
  group source_HIS_app_communication_SNMP_SNMPMib_Private_ElementGroup
    ./source/HIS/app/communication/SNMP/SNMPMib/Private/ElementGroup/: CMibNEStruct.cpp GroupCardList.cpp GroupDeviceList.cpp GroupTopology.cpp NEStructGroup.cpp TableDevice.cpp TableSlot.cpp TableTopoOption.cpp TableTopoStatus.cpp
  group source_HIS_app_communication_SNMP_SNMPMib_Private_AttributeGroup
    ./source/HIS/app/communication/SNMP/SNMPMib/Private/AttributeGroup/: CMibAttribute.cpp CMibBasicAttribute.cpp CMibCommunicationAttribute.cpp CMibDateAttribute.cpp
  group source_HIS_app_UpDataMain
    ./source/HIS/app/UpDataMain/: CMSSave.cpp Lpc3250upload.cpp Mid_FlashData.c Mid_NandFlash.c cfg_save_nand.c
  group source_HIS_app_BusinessClockSource
    ./source/HIS/app/BusinessClockSource/: ClockSource.cpp ClockSourceManager.cpp XcExtClockSource.cpp XcOPTClockSource.cpp XcLocalClockSource.cpp XcPCMClockSource.cpp F16E1PCMClockSource.cpp
  group source_HIS_app_communication_TopologyModule
    ./source/HIS/app/communication/TopologyModule/: TopoManager.cpp
  group source_HIS_app_ComponentElement_compmisc_VFCommand
    ./source/HIS/app/ComponentElement/compmisc/VFCommand/: VFCmdRegRead.cpp VFCmdTSEnable.cpp VFCmdTSLoop.cpp VFCmdTSMode.cpp VFCmdTSPolarTurn.cpp VFCmdTSRcvGain.cpp VFCmdTSSndGain.cpp VFCmdTsType.cpp VFCommand.cpp VFCmdRegWrite.cpp VFCmdCoeRead.cpp VFCmdCoeWrite.cpp VFCmdCardInit.cpp VFCmdMcuVer.cpp VFCmdSignalConfig.cpp VFCmdSignalStatus.cpp
  group source_HIS_app_AlarmModule_AlarmFrame
    ./source/HIS/app/AlarmModule/AlarmFrame/: AlarmInstance.cpp AlarmRecord.cpp BAlarmDisplay.cpp BAlarmModule.cpp BAlarmSource.cpp AlarmPropertyTemplate.cpp DisplayEverySignal.cpp DisplayMultiSignalOR.cpp
  group source_HIS_app_AlarmModule_XCAlarm
    ./source/HIS/app/AlarmModule/XCAlarm/: SrcSTMPort.cpp XCAlarmModule.cpp XCLEDLOS.cpp XCLEDALM.cpp SrcAlarmVC4.cpp SrcGroupSTMPort.cpp
  group source_HIS_app_communication_SNMP_SNMPMib_Private_AlarmGroup
    ./source/HIS/app/communication/SNMP/SNMPMib/Private/AlarmGroup/: CMibAlarm.cpp GroupAlarmProperty.cpp GroupAlarmRecord.cpp TableAlarmPropertyConfig.cpp TableAlarmPropertyTemplateConfig.cpp TableAlarmPropertyTemplateOperation.cpp TableCurrentAlarm.cpp
  group source_HIS_app_AlarmModule_E1CardAlarm
    ./source/HIS/app/AlarmModule/E1CardAlarm/: E1CardAlarmModule.cpp SrcAlarmE1.cpp E1LEDs.cpp E1Card48AlarmModule.cpp E1Card16AlarmModule.cpp E1LEDWork.cpp SrcAlarm16E1.cpp E1LEDAis.cpp
  group source_HIS_app_AlarmModule_TribSTMAlarm
    ./source/HIS/app/AlarmModule/TribSTMAlarm/: SrcTribSTMPort.cpp Trib4STM1AlarmModule.cpp Trib8STM1AlarmModule.cpp TribSTMLEDALM.cpp TribSTMLEDLOS.cpp
  group source_HIS_app_AlarmModule_EOSCardAlarm
    ./source/HIS/app/AlarmModule/EOSCardAlarm/: EOS4CardAlarmModule.cpp EOS8CardAlarmModule.cpp SrcAlarmVCG.cpp EOS4NCardAlarmModule.cpp EOS8NCardAlarmModule.cpp
  group source_HIS_app_ComponentElement_base
    ./source/HIS/app/ComponentElement/base/: ConfigCell.cpp
  group source_HIS_app_BusinessResource_OtherCardResource
    ./source/HIS/app/BusinessResource/OtherCardResource/: CHVC.cpp PortData.cpp PortE1.cpp PortVF.cpp Slot155Channel.cpp VCG.cpp PortFE1.cpp
  group source_HIS_app_BusinessResource_XCResource
    ./source/HIS/app/BusinessResource/XCResource/: CExtE1.cpp CInnerE1.cpp CSTBus.cpp CTSChannel.cpp PortSTM4.cpp RscSDHBus.cpp RscSDHChannel.cpp RscVC4.cpp RscVC12.cpp
  group source_HIS_app_BusinessResource_XCPairResource
    ./source/HIS/app/BusinessResource/XCPairResource/: PairPortSTM.cpp PairRscConnectable.cpp PairRscSDHBus.cpp PairRscVC4.cpp PairRscSDHChannel.cpp PairClockSource.cpp PairSTBus.cpp PairTSChannel.cpp PairRscVC12.cpp PairPortFE1.cpp
  group source_HIS_app_ComponentElement_Protect
    ./source/HIS/app/ComponentElement/Protect/: OMUStandby.cpp OMUStatus.cpp OMUWorking.cpp ProtectAssistCell.cpp OMUIdle.cpp SyncFileAPI.cpp SyncFileBakAPI.cpp
  group source_HIS_app_ComponentElement_compmisc_FANPOWCommand
    ./source/HIS/app/ComponentElement/compmisc/FANPOWCommand/: FANPOWOnLine.cpp CmdRing.cpp CmdFanCtrl.cpp CmdFanVer.cpp
  group source_HIS_app_AlarmModule_EmuxXCAlarm
    ./source/HIS/app/AlarmModule/EmuxXCAlarm/: DXCAlarmModule.cpp SrcAlarmUpE1.cpp UpE1LEDALM.cpp UpE1LEDWork.cpp
  group source_HIS_app_AlarmModule_FECardAlarm
    ./source/HIS/app/AlarmModule/FECardAlarm/: FE1CardAlarmModule.cpp
  group source_HIS_app_communication_SNMP_Trap
    ./source/HIS/app/communication/SNMP/Trap/: AllInOneVariable.cpp Counter32.cpp Counter64.cpp Gauge32.cpp Integer32.cpp IpAddress.cpp Null.cpp OID.cpp OctetString.cpp SNMPPdu.cpp TimeTicks.cpp TrapList.cpp Variable.cpp VariableBinding.cpp VariableBindings.cpp
  group source_HIS_app_communication_NMPort
    ./source/HIS/app/communication/NMPort/: ChannelSabit.cpp ChannelTsDcn.cpp NMChannel.cpp NMPort.cpp ChannelDcc.cpp
